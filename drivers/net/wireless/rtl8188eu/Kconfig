## drivers/net/wireless/rtl8188eu/Kconfig
```kconfig
config RTL8188EU
	tristate "Realtek 8188EU USB WiFi"
	depends on USB
    select WEXT_PRIV
	---help---
	  Help message of RTL8188EU
```
